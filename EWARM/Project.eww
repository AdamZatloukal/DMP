<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32G071RB_NUCLEO_AZ2.ewp</path>
  </project>
  <batchBuild />
</workspace>
